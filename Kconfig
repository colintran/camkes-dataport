## Kconfig
```kconfig
config APP_DATAPORT2
  bool "Example Dataport"
  default n
   help 
    Illustration of using buffer type
```
